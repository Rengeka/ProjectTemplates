## Templates/C/LinuxKernelModule/Kconfig
```kconfig
config HELLO_WORLD
    tristate "Hello World Module"
    default n
    help
      This is a simple sample kernel module template"
```
